require ${@"recipes-core/images/rcar-gen3-dev-utils.inc" if "rcar-gen3" in d.getVar("OVERRIDES") else ""}
